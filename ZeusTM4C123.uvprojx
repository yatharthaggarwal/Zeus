# Keil uVision project ZeusTM4C123.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ZeusTM4C123
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PART_TM4C123GH6PM
  c include: .\driverlib;.\Custom Libraries
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c
    ./driverlib/: startup_rvmdk.S
  group Libraries
    ./driverlib/driverlib/rvmdk/: driverlib.lib
    ./Custom Libraries/: AnalogSensor.c ControlMechanism.c Fingers.c FSRsignal.c Grips.c I2Ccustom.c IMU.c InitPorts.c InterruptHandlers.c Motor.c SerialUSB.c Timer.c
    ./driverlib/utils/: uartstdio.c
software components: CMSIS:CORE 5.1.1
